# Autodesk Inventor assembly: 답안조립품
## iProperties
Created: 2015-01
Part Number: 답안조립품
Document SubType Name: Assembly
Designer: lee
Author: lee
